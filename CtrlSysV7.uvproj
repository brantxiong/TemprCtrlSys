# Keil uVision project CtrlSysV7.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: CtrlSysV7 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Source Group 1
    ./: ADuC702x.s main.c
    ./src/: interface.c io_ctrl.c ocm12864.c serial.c temperature.c time.c int.c key.c IR.c pid_ctrl.c
